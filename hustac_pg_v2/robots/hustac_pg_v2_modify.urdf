Commit message: update packages

File: hustac_pg_v2/robots/hustac_pg_v2_modify.urdf (robot description, URDF)
Before this commit: robot hustac_pg_v2, 27 links, 26 joints
Joints:
- joint left_joint2: origin xyz=0 -0.0849999999999999 0 rpy=1.5707963267949 0 0 -> xyz=0 -0.08401108 0 rpy=1.3911 0 0
